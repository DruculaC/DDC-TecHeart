# Keil uVision project DDC-Z.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: DDC-Z +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 hSch51.c Timer.c DDC-Z.c Elecmotor.c Button.c UART.c Communication.c Speech.c Delay.c Battery.c Sensor.c Alarm.c Function.c Function-S.c Selflearn.c ISP_DataFlash.c Protection.c
